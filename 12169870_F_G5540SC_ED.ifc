Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [COBie2.4DesignDeliverable], RevitIdentifiers [VersionGUID: 31aadf33-06b4-4ca5-9c2d-34c3fa957add, NumberOfSaves: 1]
File name: 0001
Time: 2026-09-08T13:20:34+01:00
Written by: ODA SDAI 23.12
Made in: Autodesk Revit 24.0.20.20 (ENU) - IFC 24.0.20.20

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Pset_ProductRequirements - Category: Project Information

# IfcBuildingElementProxy: 12169870_F_G5540SC_ED:21554018_F_12169870_G5540SC_ED, (2)
In: Default
Type - Material: z_Miele_Design_Glass Black, z_Miele_Design_CLST, z_Miele_Connection_Electric, z_Miele_Connection_Water_OUT, z_Miele_Connection_Water_IN, Polypropylene, z_Miele_Design_Steel_Chrom
Type - Pset_ManufacturerTypeInformation - Manufacturer: Miele
Type - Pset_ProductRequirements - Category: Specialty Equipment
Type - Pset_ProvisionForVoid - Width: 448 mm; Height: 845 mm; Depth: 600 mm
Classification: E1030.80 Uniformat (Uniformat)
Pset_BuildingElementProxyCommon - Reference: 21554018_F_12169870_G5540SC_ED; sets with these values: 2

# IfcDistributionPort, Port_357888_1
Description: Flow; FlowDirection: SOURCEANDSINK
